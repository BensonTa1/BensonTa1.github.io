//  ******************************************************************************  
//   
simulator lang=spectre insensitive=yes 
//  Property of UMC.   
//  Unauthorized reproduction, modification and/or distribution are strictly   
//  prohibited.   
//  This product is protected under copyright law and trade secret law.   
//  This model card may not be sent in any form outside of UMC without   
//  the written consent of the UMC ATD Modeling Division.   
//  ******************************************************************************  
//   
//  Process:  0.11 um Logic and Mixed-Mode 1P8M Metal Metal Capacitor Al Advanced  
// Enhancement Process    
//  Device Type:  P+ unsalicided Poly resistor RF subcircuit model     
//  Simulator:  SPECTRE   
//  Model Version:0.2 p1   
//  ******************************************************************************  
//   
//  Revision history:   
//  <Revision 1>   
//  Version : 0.1_p1   
//  Date  : 2010/02/05   
//  Owner : Ian Chen   
//  Comment : Original release.   
//  <Revision 2>   
//  Version : 0.1_p2   
//  Date  : 2010/04/12   
//  Owner : Shih-Hsin Yeh   
//  Comment : Revise Rend, Rsh, tcr1, tcr2, vcr1, vcr2, and dw based on EDR.   
//  <Revision 3>   
//  Version : 0.2_p1   
//  Date  : 2010/07/22   
//  Owner : Yealing Lin    
//  Comment : Modify RF model based on new silicon data.   
//  **************************************************************************************  
//   
//     Model coverage:   
//     1. Width (w): 0.5um ~ 2.0um   
//     2. Length (l): 5.0um ~ 20um   
//     3. Frequency range: 100MHz ~ 20.1GHz   
//     4. Temperature Range: -50C to 125C   
//     5: Biasing range:  < 0.5mA/(um width)   
//    
//     Node definition:   
//     1. port1    
//     2. port2    
//     3. sub:  psub   
//     4. nwell   
//  ********************************************************************   
subckt rnppo_rf ( port1 port2 nwell psub )  
parameters 
+ l=10u          
+ w=1u                      
+ dx=1.68u 
+ dy=1.68u                
+ le=0.46u                  
+ lend=0.18e-06 
+ rend=36.5e-6+drend_rnppo_rf                         
+ rs=239+drs_rnppo_rf 
+ tcr1=9.67e-5             
+ tcr2=5.60e-7              
+ vcr1=0 
+ vcr2=0.0586e-12        
+ dw=-0.0405e-06+ddw_rnppo_rf 
+ p_area=w*0.9*l*0.9*1e12
+ p_cox=(1.6776368e-15+7.3234741e-19*(p_area**2.5)-6.0908075e-16/(p_area**0.5)+(3.7468067e-18*log(p_area**0.5))/p_area**2)*(1+p_cox_rnppo_rf) 
+ p_rs=100
+ p_r=((2*rend+rs*l*0.9)/(w*0.9+dw)*(1.0+(tcr1*(temp-25))+tcr2*(temp-25)*(temp-25))) 
+ p_cs2=3.93063e-15+1.34007e-17*(p_area**2)-1.1292e-15*(p_area**0.5)-2.8098e-16/(p_area**2) 
+ vc1=vcr1/(l*0.9)        
+ vc2=vcr2/(l*0.9)/(l*0.9)  
+ nw_area=(l+2*le+2*dx)*(w+dy+dx) 
+ nw_pj=2*(l+w+2*le+2*dx+dy+dx)
//*------equivalentnetwork-------------
r1 (port1 _node12) resistor r=p_r*(1.0+vc1*abs(v(port1, _node12)/(l*0.9*1e6))+vc2*pow(abs(v(port1, _node12))/(l*0.9*1e6),2))/2
r2 (_node12 port2) resistor r=p_r*(1.0+vc1*abs(v(_node12, port2)/(l*0.9*1e6))+vc2*pow(abs(v(_node12, port2))/(l*0.9*1e6),2))/2
cox1 (port1 _node61) capacitor c=p_cox
cox2 (port2 _node62) capacitor c=p_cox
cox3 (_node12 _node63) capacitor c=p_cox
rsub1 (_node61 nwell) resistor r=p_rs
rsub2 (_node62 nwell) resistor r=p_rs
rsub3 (_node63 nwell) resistor r=p_rs
cs1 (port1 _node12) capacitor c=p_cs2
cs2 (_node12 port2) capacitor c=p_cs2
dnw (psub nwell) nwell_psub_dio area=nw_area pj=nw_pj
model nwell_psub_dio diode
+ hcomp=1.0000e+00        imax=1.00e+14             level=1 
+ ibv=5.952               ik=17856                  ikp=595.2 
+ is=2.05e-006            isw=5.34e-011             n=1.0525 
+ rs=3.0891e-007          bv=9.662                  cjo=8.28e-005 
+ vj=0.588                mj=0.474                  cjp=9.92e-010 
+ mjsw=0.27               vjsw=0.62                 tlev=1 
+ tlevc=1                 tnom=25                   eg=1.16 
+ xti=5.4936              cta=0.00332               ctp=0.001 
+ tbv1=-0.000539          pta=0.0028                ptp=0.001 
+ trs=0.00322
ends rnppo_rf 
  
