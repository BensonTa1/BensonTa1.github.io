//********************************************************************************
//* Property of UMC.
//* Unauthorized reproduction, modification and/or distribution are strictly
//* prohibited.
//* This product is protected under copyright law and trade secret law.
//* This model card may not be sent in any form outside of UMC without
//* the written consent of the UMC ATD Modeling Division.
//********************************************************************************
//* Process:      0.11um Logic Low Leakage RF CMOS Process
//* Device Type:  N- and P-FET  
//* Description:  1.2V MOS Transistor
//* Model:        Subcircuit BSIM3.2.4 RF model(SPECTRE)
//* Simulator:    SPECTRE 
//* Model Version:0.2 p1
//* Model Features:
//*     Global model:  Yes
//*     Igate model:  Yes
//*     GIDL model: No
//*     Substrate current model: Yes
//*     Flicker noise: Yes
//*     LOD model: Yes
//*     RF model: Yes
//*     Well proximity effect: No
//********************************************************************************
//* Revision History:
//*
//* <Revision 1>                            
//* Version : 0.2 phase 1                   
//* Date    : 2011/3/7               
//* Author  : Daniel Wan, Peiming Lei                     
//* Remark  : 1.Original release
//*           2.silicon-based model
//********************************************************************************
//* 1.2V LL pwell RF NMOS transistor
//*
//* Geometry range:
//*   Finger width(wf) : 0.9um ~ 7.2um 
//*   Finger length(lf): 0.12um ~ 0.36um 
//*   Finger no.(nf)   : 2 ~ 22 
//* 
//* Voltage range:
//*   0V <= VGS <= 1.2V
//*   0V <= VDS <= 1.2V
//*         VBS  = 0V
//*
//* Temperature range:
//*   -50c ~ 125c ; nominal temperature=25c.
//*
//* Frequency range:
//*   Up to 20.1GHz
//*
//* Node Definition:
//*   drain : 1 
//*   gate  : 2
//*   source: 3
//*   body  : 4
//*
//********************************************************************************
//* 1.2V LL RF PMOS transistor
//*
//* Geometry range: 
//*   Finger width(wf) : 1.6um ~ 9.6um 
//*   Finger length(lf): 0.12um ~ 0.36um 
//*   Finger no.(nf)   : 2 ~ 22 
//* 
//* Voltage range:
//*   -1.2V <= VGS <= 0V
//*   -1.2V <= VDS <= 0V
//*            VBS  = 0V
//*
//* Temperature range:
//*   -50c ~ 125c ; nominal temperature=25c.
//*
//* Frequency range:
//*   Up to 20.1GHz
//*
//* Node Definition:
//*   drain : drain 
//*   gate  : gate
//*   source: source
//*   body  : body
//*   psub  : P-substrate(should be ground)
//*
//******************************************************************************* 
//*  1.2V LL twell RF NMOS transistor  
//*   
//* Geometry range:  
//* Finger width(wf) : 0.9um ~ 7.2um  
//* Finger length(lf): 0.12um ~ 0.36um  
//* Finger no.(nf) : 2 ~ 22  
//*  
//*  Voltage range:  
//*  0V <= VGS <= 1.2V  
//*  0V <= VDS <= 1.2V  
//*    VBS  = 0V  
//*   
//*  Temperature range:  
//*  -50c ~ 125c ; nominal temperature=25c.  
//*   
//*  Frequency range:  
//*  Up to 20.1GHz  
//*   
//*  Node Definition:  
//*  drain : 1   
//*  gate  : 2  
//*  source: 3 
//*  body  : 4 
//*  nwell : 5 
//*  psub  : 6 
//* 
//***************************** Start of Model Card ******************************

simulator lang=spectre insensitive=yes
inline subckt n_12_llrf 1 2 3 4     
parameters lf=0.12u wf=2.4u nf=16 sa=2.2u sb=2.2u dtemp=0 
+ nf_odd=nf-2*int(nf/2) 
+ nf_even=1-nf_odd fac=0.0001
+ sp_poly=0.40e-6 
+ sp_edge=0.34e-6 
+ xgw=0.18e-6 
+ no_cnt=1 
+ no_via=3 
+ sp_sub_w=1.7e-6 
+ sp_sub_l=14e-6 
+ sp_twell_w=2.24e-6 
+ sp_twell_l=1.48e-6 
+ sp_nwell_w=3.74e-6 
+ sp_nwell_l=2.98e-6 
+ wg=wf*0.9 
+ lg=(lf*0.9+12e-9) 
+ p_area_s=nf_odd*(sp_edge*(wf)+sp_poly*(wf)*(nf-1)/2)+ 
+  nf_even*(2*sp_edge*(wf)+sp_poly*(wf)*(nf/2-1)) 
+ p_area_d=nf_odd*(sp_edge*(wf)+sp_poly*(wf)*(nf-1)/2)+ 
+  nf_even*(sp_poly*(wf)*nf/2) 
+ p_pj_s=nf_odd*(sp_edge*2+(wf)+(nf-1)/2*sp_poly*2)+nf_even  
+ *(sp_edge*2*2+(wf)*2+(nf/2-1)*sp_poly*2) 
+ p_pj_d=nf_odd*(sp_edge*2+(wf)+(nf-1)/2*sp_poly*2)+nf_even  
+ *(nf/2*sp_poly*2) 
+ p_pj_sg=nf*(wf) 
+ p_pj_dg=nf*(wf) 
+ dev_l=(nf-1)*4e-007+nf*lg+1.88e-006 
+ dev_w=wg+1.04e-006 
+ dev_access=dev_l*dev_w/(16*(dev_l*dev_l+dev_w*dev_w)) 
+ rbulk=75.46*dev_access-7992*wg+1.764e+004*lg+0.000503*nf 
+ rsh=8.5 
+ hdif=1.25e-07 
+ tcig=1+1.55e-3*(temp+dtemp-25) 
+ area=wg*(lg)*1e4*tcig*nf 
+ toxg=(2.64e-09+dtox_n_12_llrf)*1e2 
+ vdf0=3.11 
+ vdfl=-0.3e-08 
+ vdfw=3.5e-09 
+ vaf0=0.7 
+ vafl=-0.8e-10 
+ vafw=1.0e-10 
+ vdr0=5.78 
+ vdrl=0e-07 
+ vdrw=5.0e-09 
+ var0=0.60 
+ varl=0e-07 
+ varw=1.0e-10 
+ vdf=(vdf0+vdfl/(lg)+vdfw/(wg))*2.6e7*toxg 
+ vaf=(vaf0+vafl/(lg)+vafw/(wg))*2.6e7*toxg 
+ vdr=(vdr0+vdrl/(lg)+vdrw/(wg))*2.6e7*toxg 
+ var=(var0+varl/(lg)+varw/(wg))*2.6e7*toxg 
+ igf=2.1e-7*area*exp(-vdf)*pow(1/toxg,2.0) 
+ igr=2.1e-7*area/(lg)*exp(-vdr)*pow(1/toxg,2.0) 
n_12_llrf ( 10 20 30 40 ) n_12_llrf_main m=nf l=lf w=wf ad=0 as=0 pd=0 ps=0 sa=2.2u  
+  sb=2.2u 
rgc ( 2 22 ) resistor r=40.36*1e-12/(lg*wg*nf)*(1+drgc_n_12_llrf) 
rgi ( 22 21 ) resistor r=(3.2*wg/lg/nf)*(1+drgi_n_12_llrf) 
rch ( 21 20 ) resistor r=(1.21e3*lg/wg/nf)*(1+drch_n_12_llrf) isnoisy=0 
rdrain ( 1 10 ) resistor r=29.703*1e-6/(wg*nf) 
rsource ( 3 30 ) resistor r=29.703*1e-6/(wg*nf) 
rsubd ( 40 45 ) resistor r=7900*(0.4u+lg)/(wg*nf) 
rsubs ( 44 40 ) resistor r=7900*(0.4u+lg)/(wg*nf) 
rsubbe ( 40 4 ) resistor r=80*rbulk 
cgs_ext ( 22 30 ) capacitor c=1e-16*(3.46e-3*nf*nf+3.195*nf+4.615)* 
+  (1+dcgd_ext_n_12_llrf) 
cgd_ext ( 22 10 ) capacitor c=1e-16*(3.46e-3*nf*nf+3.195*nf+4.615)* 
+  (1+dcgd_ext_n_12_llrf) 
cds_ext ( 30 10 ) capacitor c=1e-16*(1.99e-4*wg*wg*nf*nf/lg/lg+0.347  
+ *wg*nf/lg+3.5)*(1+dcds_ext_n_12_llrf) 
djsb ( 44 30 ) sd_diode_core_nchpw m=1 area=p_area_s pj=p_pj_sg 
djsb_p ( 44 30 ) sdp_diode_core_nchpw m=1 area=1e-20 pj=p_pj_s 
djdb ( 45 10 ) sd_diode_core_nchpw m=1 area=p_area_d pj=p_pj_dg 
djdb_p ( 45 10 ) sdp_diode_core_nchpw m=1 area=1e-20 pj=p_pj_d 
//  ****Igate model*******************************************************************************  
//   
gigcd ( 20 10 ) bsource i =igf*pow((abs(v(20,10))+v(20,10))/2,vaf)-igr* 
+  pow((abs(v(20,10))-v(20,10))/2,var) 
gigcs ( 20 30 ) bsource i =igf*pow((abs(v(20,30))+v(20,30))/2,vaf)-igr* 
+  pow((abs(v(20,30))-v(20,30))/2,var) 
//  ***********************************************************************************************  
//   
  
model n_12_llrf_main bsim3v3 type=n  
+  version=3.24              lmin=1.08e-007            lmax=3.24e-007 
+  wmin=8.1e-007            wmax=6.48e-006               binunit=2 
+  mobmod=1                  capmod=3                  nqsmod=0 
+  stimod=1                  tnom=25                    
+  tox=2.64e-009+dtox_n_12_llrf                      toxm=2.64e-009 
+  wint=7.28e-008            lint=1.0136e-008          dlc=4.085e-009 
+  dwc=4.507e-007            hdif=1.25e-007            ldif=9e-008 
+  xl=-9e-009+dxl_n_12_llrf+12e-009               
+  xw=1.4e-008+dxw_n_12_llrf                         xj=1.07e-007 
+  ngate=3.253e+021          ll=-2.4375e-012           wl=2e-015 
+  lln=0.5043                wln=1.04                  lw=5.94e-015 
+  ww=-2.228e-010            lwn=1                     wwn=0.354 
+  lwl=-4.617e-018           wwl=-1.8679e-017+dwwl_n_12_llrf 
+  llc=8.344e-012            wlc=0                     lwc=0 
+  wwc=-2.594e-009           lwlc=6.2e-019             wwlc=-8.316e-018 
+  xpart=0                   vth0=0.4496+dvth0_n_12_llrf 
+  pvth0=-3.073e-016+dpvth0_n_12_llrf              vfb=-0.8674 
+  k1=0.5537                 k2=-0.02355               k3=2.207+dk3_n_12_llrf 
+  lk3=4.2095e-006           wk3=-1.5411e-006          pk3=2.3441e-015 
+  k3b=-1                    wk3b=8.902e-007           pk3b=1.557e-013 
+  nlx=1.9077e-007+dnlx_n_12_llrf                    w0=5.514e-007 
+  dvt0=2.4277               dvt1=0.31156              dvt2=-0.0002724 
+  dvt0w=0.208               wdvt0w=9e-008             pdvt0w=-2.2782e-014 
+  dvt1w=800800              dvt2w=-0.0125             nch=7.35e+017 
+  voff=-0.1218              lvoff=-4.8e-009           pvoff=-1.6072e-015 
+  nfactor=0.19632           lnfactor=6.1834e-008      cdsc=5e-005 
+  cdscb=0                   cdscd=1e-005              cit=0.001921 
+  alpha0=4.557e-010         alpha1=0.00018            beta0=7.3 
+  lbeta0=-4.08e-008         eta0=0.07285              etab=-0.03213 
+  dsub=0.65162              pdsub=-1.8986e-014+dpdsub_n_12_llrf 
+  u0=0.03229+du0_n_12_llrf                          pu0=1.106e-014 
+  ua=0                      lua=7.879e-017            ub=6.836e-019 
+  lub=-1.96e-025            uc=4.961e-011             wuc=6.42e-019 
+  puc=1.2e-024              prwg=8.511                lprwg=-2.613e-007 
+  pprwg=-4.08e-013          prwb=-0.1656              wr=1 
+  rdsw=37.96+drdsw_n_12_llrf                        a0=1.822 
+  la0=2.59e-007             ags=0.1644+dags_n_12_llrf 
+  wags=0+dwags_n_12_llrf                            lags=9.014e-007 
+  a1=0.001913               a2=0.2936                 la2=1.03e-008 
+  b0=2.533e-007             pb0=4.8435e-020           b1=1.247e-006 
+  wb1=-1.4599e-013          vsat=67980+dvsat_n_12_llrf 
+  lvsat=0.0091724           pvsat=1.0226e-009+dpvsat_n_12_llrf 
+  keta=-0.046               lketa=7.8e-009            wketa=3.6e-009 
+  delta=0.02181             ldelta=2.903e-009         dwg=-1.965e-009 
+  pdwg=7.215e-024           dwb=4.807e-009            pclm=1.022 
+  lpclm=5.8748e-008         ppclm=8.046e-014          pdiblc1=0.006525 
+  ppdiblc1=1.176e-014       pdiblc2=0.004753          pdiblcb=-0.496 
+  drout=0.63792             pvag=1.187                pscbe1=4.24e+008 
+  pscbe2=1e-005             elm=5                     clc=5.808e-007 
+  cle=0.8204                cf=9.059e-011+dcf_n_12_llrf*fac 
+  ckappa=0.0064             acde=0.4                  moin=5.04 
+  lmoin=5.209e-007          vfbcv=-1.5                noff=2.016 
+  lnoff=8.44e-008           wnoff=2e-007              voffcv=-0.06344 
+  lvoffcv=-5.326e-009       cgbo=0                     
+  cgso=1.865e-010+dcgso_n_12_llrf*fac              
+  cgdo=1.865e-010+dcgdo_n_12_llrf*fac              
+  cgdl=3.16e-011+dcgdl_n_12_llrf*fac               
+  cgsl=3.16e-011+dcgsl_n_12_llrf*fac              kt1=-0.2615 
+  kt1l=1.481e-009           kt2=-0.0422               ute=-1.314 
+  wute=3.725e-008           pute=1.997e-014           ua1=2.951e-009 
+  ub1=-3.017e-018           uc1=-8.945e-011           prt=-194.1 
+  lprt=2.5e-005             at=122900                 wat=0.001815 
+  noia=2.73e+021            noib=44850                noic=-2.87e-014 
+  em=6658000                ef=0.8344                 noimod=2 
+  rsh=8.5                   js=8.81e-008              jsw=9.61e-014 
+  cj=0                      mj=0.258                  cjsw=0 
+  mjsw=0                    cjswg=0                   mjswg=0.7166 
+  pb=0.56                   pbsw=0.54                 pbswg=1.11 
+  xti=3                     tpb=0.001632              tpbsw=0.00031 
+  tpbswg=0.00182            tcj=0.0009555             tcjsw=0.0007325 
+  tcjswg=0.001436           nj=1.008                  saref=2.2e-006 
+  sbref=2.2e-006              wlod=0                    kvth0=3e-009 
+  lkvth0=-2.71e-011         wkvth0=0                  pkvth0=0 
+  llodvth=1                 wlodvth=1                 stk2=4e-010 
+  lodk2=1                   lodeta0=1                 ku0=-5.32e-008 
+  lku0=5.776e-008           wku0=0                    pku0=0 
+  llodku0=1.12              wlodku0=1                 kvsat=0.9 
+  steta0=0                  tku0=0                     
+  imax=0.1                  minr=0.01
  
model sd_diode_core_nchpw diode  
+  hcomp=1.0000e+00          imax=1.00e+14             level=1 
+  is=8.81e-08               isw=9.61e-14              n=1.008 
+  rs=0                      ik=5.28e+04               ikp=2780 
+  bv=13.36                  ibv=27.78                 trs=0.000495 
+  eg=1.16                   tbv1=-0.000684            tnom=25 
+  xti=3                     tlev=1                    tlevc=1 
+  cjo=0.00072+dcj_n_12_llrf                   mj=0.258 
+  vj=0.56                   cjsw=9.94e-11+dcjsw_n_12_llrf 
+  mjsw=0.13                 vjsw=0.54                 pta=0.001632 
+  ptp=0.00031               cta=0.0009555             ctp=0.0007325 
model sdp_diode_core_nchpw diode  
+  hcomp=1.0000e+00          imax=1.00e+14             level=1 
+  tnom=25                   cjo=0                      
+  cjsw=5e-10+dcjswg_n_12_llrf                 mjsw=0.7166 
+  vjsw=1.11                 ctp=0.001436              xti=3 
+  eg=1.16                   tlev=0                    tlevc=1 
ends n_12_llrf 

simulator lang=spectre insensitive=yes
setoption1 options gmin=1e-13
//  * 1.2V HS RF PMOS transistor ***
inline subckt p_12_llrf ( drain gate source body psub ) 
parameters lf=0.12u wf=2.4u nf=16 sa=2.2u sb=2.2u dtemp=0 
+ nf_odd=nf-2*int(nf/2) nf_even=1-nf_odd        
+ sp_poly=0.40e-6 sp_edge=0.34e-6 xgw=0.18e-6 no_cnt=1 no_via=3 sp_sub_w=1.7e-6
+ sp_sub_l=0.94e-6  sp_nwell_w=2.337e-6 sp_nwell_l=1.52e-6   
+ wg=wf*0.9 lg=lf*0.9+12e-9
+ p_area_s=nf_odd*(sp_edge*(wf)+sp_poly*(wf)*(nf-1)/2)+nf_even*(2*sp_edge*(wf)+sp_poly*(wf)*(nf/2-1))
+ p_area_d=nf_odd*(sp_edge*(wf)+sp_poly*(wf)*(nf-1)/2)+nf_even*(sp_poly*(wf)*nf/2)
+ p_pj_s=nf_odd*(sp_edge*2+(wf)+(nf-1)/2*sp_poly*2)+nf_even*(sp_edge*2*2+(wf)*2+(nf/2-1)*sp_poly*2)
+ p_pj_d=nf_odd*(sp_edge*2+(wf)+(nf-1)/2*sp_poly*2)+nf_even*(nf/2*sp_poly*2)
+ p_pj_sg=nf*(wf)
+ p_pj_dg=nf*(wf)
+ p_area_nw=((wf)+2*sp_nwell_w)*(2*sp_edge+nf*(lf+8e-9)+(nf-1)*sp_poly+2*sp_nwell_l)
+ p_pj_nw=2*((wf)+2*sp_nwell_w+ 2*sp_edge+nf*(lf+8e-9)+(nf-1)*sp_poly+2*sp_nwell_l)
+ dev_l = (nf-1)*0.4u + nf*lg + 1.88u
+ dev_w = wg + 1.04u
+ dev_access = dev_l * dev_w/(16*(dev_l*dev_l+dev_w*dev_w))
+ rbulk =  31.1 * dev_access -7992*wg + 1.764e+004*lg + 0.006852*nf 
//***Igate model***
+ rsh=7.6  
+ hdif=1.25e-07 
+ tcig=1 + 2.25e-3 * (temp + dtemp - 25) 
+ area=wg * lg * 1e4 * tcig * nf 
+ toxg=(2.83e-09 + dtox_p_12_llrf) * 1e2 
+ vdf0=3.22 vdfl= - 7.00e-09 vdfw= - 6.0e-8 
+ vaf0=0.6 vafl= - 1.5e-08 vafw= - 3.0e-8 
+ vdr0=5.50 vdrl= + 1.50e-08 vdrw= - 1.0e-07 
+ var0=0.35 varl= + 1.50e-08 varw=4.0e-8 
+ vdf=(vdf0 + vdfl / (lg) + vdfw / (wg)) * 2.6e7 * toxg 
+ vaf=(vaf0 + vafl / (lg) + vafw / (wg)) * 2.6e7 * toxg 
+ vdr=(vdr0 + vdrl / (lg) + vdrw / (wg)) * 2.6e7 * toxg 
+ var=(var0 + varl / (lg) + varw / (wg)) * 2.6e7 * toxg 
+ igf=2.1e-7 * area * exp( - vdf) * pow(1 / toxg,2.0) 
+ igr=2.1e-7 * area / (lg) * exp( - vdr) * pow(1 / toxg,2.0) 
// 
gigcd ( 20 10 ) bsource i = - igf * pow((abs(v(20,10)) - v(20,10)) / 2,vaf) 
+ + igr * pow((abs(v(20,10)) + v(20,10)) / 2,var)
gigcs ( 20 30 ) bsource i = - igf * pow((abs(v(20,30)) - v(20,30)) / 2,vaf) 
+ + igr * pow((abs(v(20,30)) + v(20,30)) / 2,var) 
//  
p_12_llrf ( 10 20 30 40 ) p_12_llrf m=nf l=lf w=wf ad=0 as=0 pd=0 ps=0 sa=2.2u sb=2.2u
// 
rgc ( gate 22 ) resistor r=80.2 / nf * (1 + 4.6u / wg) * (1 + drgc_p_12_llrf)
rgi ( 22 21 ) resistor r=0.8 * wg / (lg * nf) * (1 + drgi_p_12_llrf)
rch ( 21 20 ) resistor r=(lg * lg * 3 * nf * 5e11 - lg * nf * 2e5 + 0.58) * (1 + 
+ drch_p_12_llrf) isnoisy = 0
 
rdrain ( drain 10 ) resistor r=6.383e-006 / (wg * nf)
rsource ( source 30 ) resistor r=6.383e-006 / (wg * nf)
rsubd ( 40 45 ) resistor r=6.4e-3/(1+4/(wg*wg*1e12))/(wg*nf)
rsubs ( 44 40 ) resistor r=6.4e-3/(1+4/(wg*wg*1e12))/(wg*nf)
rsubb ( 40 body ) resistor r=1.8 * rbulk
//
cgs_ext ( 22 30 ) capacitor c=0.22 * (1.9e-12 * (0.125 * wg + 8.8e-6) * (nf + 2) 
+ + 2.14e-22 / wg * nf) * (1 + dcgd_ext_p_12_llrf)
cgd_ext ( 22 10 ) capacitor c=(2.1e-11 * (0.125 * wg + 8.8e-6) * (nf + 2) + 2.2e-23 
+ / wg * nf) * (1 + lg * 8.4e6) * (1 + dcgd_ext_p_12_llrf)
cds_ext ( 30 10 ) capacitor c=1.043e-016 * wg * nf * 1e6 * (1 + dcds_ext_p_12_llrf)
djsb ( 30 44 ) sd_diode_core_pch m=1 area=p_area_s pj=p_pj_sg
djsb_p ( 30 44 ) sdp_diode_core_pch m=1 area=1e-20 pj=p_pj_s
djdb ( 10 45 ) sd_diode_core_pch m=1 area=p_area_d pj=p_pj_dg
djdb_p ( 10 45 ) sdp_diode_core_pch m=1 area=1e-20 pj=p_pj_d
dbsub ( 50 body ) nw_psub_diode area=p_area_nw pj=p_pj_nw
rbsub ( psub 50 ) resistor r=390 * dev_access
//  *************************************************************************************************
//  * core device model
//  
model p_12_llrf bsim3v3 type=p 
+ lmin=1.2e-007            lmax=3.6e-007             wmin=1.44e-006
+ wmax=9e-005               version=3.24              mobmod=1
+ capmod=3                  nqsmod=0                  binunit=2
+ binflag=0                 tnom=25
+ xl=3e-009 + dxl_p_12_llrf                           xw=4e-009 + dxw_p_12_llrf
+ lmlt=1                    wmlt=1                    llc=-6.3346e-015
+ lwc=2.2446e-014           lwlc=-8e-023              wlc=-3.6348e-015
+ wwc=-1.6972e-015          wwlc=-5.7786e-022         
+ tox=2.83e-009 + dtox_p_12_llrf                      toxm=2.83e-009
+ wint=-5.0234e-010         lint=1.37 *  - 3.951e-008
+ dlc=1.12 * 3.9684e-008    dwc=-1.0174e-008          hdif=1.25e-007
+ ldif=9e-008               ll=1.35 * 1.3732e-014     wl=-3.1247e-015
+ lln=0.93                  wln=1                     lw=-2.4593e-014
+ ww=-1.9994e-014           lwn=0.88717               wwn=0.94291
+ lwl=-8e-023               wwl= - 5.7786e-022 + dwwl_p_12_llrf
+ cgbo=0                    cgso=1.6275e-010 + dcgso_p_12_llrf
+ cgdo=1.6275e-010 + dcgdo_p_12_llrf                  xpart=0
+ vth0= - 0.473 + dvth0_p_12_llrf                     
+ pvth0=0 *  - 1.7246e-015 + dpvth0_p_12_llrf         k1=0.62703
+ k2=-0.025799              k3= - 3.7095 + dk3_p_12_llrf
+ pk3=0 *  - 1.5253e-013    k3b=3.5815                pk3b=5.2978e-014
+ nlx=2.693e-008 + dnlx_p_12_llrf                     dvt0=0.56325
+ dvt1=1                    dvt2=-0.29456             dvt0w=0
+ dvt1w=5899600             dvt2w=-9.6991e-005        nch=1.3908e+017
+ voff=-0.13015             lvoff=-2.8535e-009        wvoff=-1.0272e-009
+ nfactor=2                 wnfactor=-4.5789e-007     cdsc=0.0072719
+ cdscb=0.0054657           cdscd=0.002               cit=0.00061551
+ u0=0.011109 + du0_p_12_llrf                         
+ wu0=0 *  - 1.2111e-009 + dwu0_p_12_llrf             pu0=0 + dpu0_p_12_llrf
+ ua=1.2691e-009            ub=6.8645e-019            uc=-7.2275e-011
+ luc=9.5728e-018           ngate=1e+021              xj=1.17e-007
+ w0=5e-011                 prwg=0.0084443            prwb=-0.010128
+ pprwb=-6.84e-014          wr=0.95955                
+ rdsw=151.97 + drdsw_p_12_llrf                       lrdsw=2.6333e-006
+ prdsw=0 * 1.1183e-011     a0=2.2611                 
+ ags=0.4 * 0.67467 + dags_p_12_llrf                  
+ lags=1.15 * 6.8073e-007 + dlags_p_12_llrf           
+ wags=-2.0353e-009 + dwags_p_12_llrf           
+ pags=-7.5e-014 + dpags_p_12_llrf              a1=0.04361
+ a2=0.999                  b0=4.8139e-006            b1=1.0465e-005
+ vsat=233060                       
+ pvsat=0 *  - 9.5901e-009          keta=0
+ pketa=-4.9e-015           dwg=-4.8728e-008          dwb=2.7414e-009
+ alpha0=5.6e-006           beta0=22.35               pclm=1.7447
+ pdiblc1=0.004272          pdiblc2=0.0238997         pdiblcb=0
+ drout=0.6                 pvag=0                    pscbe1=5.51e+008
+ pscbe2=8.94e-008          delta=1.3 * 0.03          eta0=0.8 * 0.06599999
+ peta0=0 *  - 1e-015       etab=-0.0481              dsub=0.639133
+ elm=5                     alpha1=11.55              vfb=-0.9414849
+ cf=8.9044e-011 + dcf_p_12_llrf                      ckappa=0.034469
+ cgdl=8.3591e-011 + dcgdl_p_12_llrf                  
+ cgsl=8.3591e-011 + dcgsl_p_12_llrf                  acde=0.65
+ moin=8.662                noff=2.2452               voffcv=-0.0069387
+ lvoffcv=-5.9397e-009      clc=1e-8                  cle=0.6
+ kt1=-0.28831              wkt1=1.1292e-008          kt1l=-6.0507e-010
+ kt2=-0.045365             ute=-0.8                  ua1=4.2166e-009
+ ub1=-5.5472e-018          wub1=1.0602e-025          uc1=-2.6739e-010
+ prt=-219.63               at=119260                 noimod=2
+ ef=0.8064669              em=1.1e+008               noia=2.7e+018
+ noib=10000                noic=5.42e-011            rsh=7.67
+ js=3.6e-007               jsw=5e-013                
+ cj=0.000969 + dcj_p_12_llrf                         mj=0.308
+ cjsw=1.18e-010 + dcjsw_p_12_llrf                    mjsw=0.1
+ pb=0.687                  rd=0                      rdc=0
+ rs=0                      rsc=0                     xti=3 
+ pbsw=0.45                 cjswg=5.31e-010 + dcjswg_p_12_llrf
+ pbswg=0.5                 mjswg=0.391               tcj=0.0010049
+ tcjsw=0.0005243           tcjswg=0.00052907         tpb=0.0017088
+ tpbsw=0.0025864           tpbswg=0.00092365         saref=2.2e-006
+ sbref=2.2e-006              wlod=0                    kvth0=0
+ lkvth0=0                  wkvth0=0                  pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=-3e-010
+ lodk2=1                   lodeta0=1                 ku0=7.42e-008
+ lku0=1.957e-008           wku0=0                    pku0=0
+ llodku0=1.15              wlodku0=1                 kvsat=1
+ steta0=0                  tku0=0                    
+  imax=0.1                  minr=0.001 
model sd_diode_core_pch diode  allow_scaling=1
+ level=3                   ibv=27.778                ik=5.78e4
+ ikr=2.78e3                is=0.00e-14               isw=0e-13
+ n=1.017                   rs=0                      vb=10.64
+ 
+ cj=1.55 * (1.92e-3 + 4.9e-11 / lf) * (1 + dcj_p_12_llrf)
+ vj=0.687                  m=0.308                   
+ cjsw=1.18e-10 + dcjsw_p_12_llrf                     mjsw=0.5
+ vjsw=0.45                 tlev=1                    tlevc=1
+ tnom=25                   eg=1.16                   xti=3
+ cta=0.0010049             ctp=0.0005243             tcv=-6.45e-4
+ pta=0.0017088             ptp=0.0025864             trs=-1.14e-4
+ ns=1.017                  nz=1.017
model sdp_diode_core_pch diode  allow_scaling=1
+ level=3                   cj=0                      
+ cjsw=4.82e-010 + dcjswg_p_12_llrf                   mjsw=0.391
+ vjsw=0.5                  tlev=1                    tlevc=1
+ tnom=25                   eg=1.16                   xti=3
+ ctp=0.00204               ptp=0.00203               
model nw_psub_diode diode  allow_scaling=1
+ level=3                   ibv=5.952                 ik=517.6627
+ ikr=595.2                 is=2.05e-6                isw=5.34e-11
+ n=1.0525                  rs=0                      vb=9.662
+ cj=8.28e-5 * (1 + dcj_nw_p_12_llrf)                 vj=0.588
+ m=0.474                   cjsw=9.92e-10 * (1 + cjsw_nw_p_12_llrf)
+ mjsw=0.27                 vjsw=0.62                 tlev=1
+ tlevc=1                   tnom=25                   eg=1.16
+ xti=5.4936                cta=3.32e-3               ctp=1e-3
+ tcv=-5.39e-4              pta=2.8e-3                ptp=1e-3
+ trs=3.22e-3               ns=1.0525                 nz=1.0525
ends p_12_llrf

inline subckt n_12bpw_llrf 1 2 3 4 5 6    
parameters lf=0.12u wf=2.4u nf=16 sa=2.2u sb=2.2u dtemp=0 
+ nf_odd=nf-2*int(nf/2) 
+ nf_even=1-nf_odd fac=0.0001
+ sp_poly=0.40e-6 
+ sp_edge=0.34e-6 
+ xgw=0.18e-6 
+ no_cnt=1 
+ no_via=3 
+ sp_sub_w=1.7e-6 
+ sp_sub_l=14e-6 
+ sp_twell_w=2.24e-6 
+ sp_twell_l=1.48e-6 
+ sp_nwell_w=3.74e-6 
+ sp_nwell_l=2.98e-6 
+ wg=wf*0.9 
+ lg=(lf*0.9+12e-9) 
+ p_area_s=nf_odd*(sp_edge*(wf)+sp_poly*(wf)*(nf-1)/2)+ 
+  nf_even*(2*sp_edge*(wf)+sp_poly*(wf)*(nf/2-1)) 
+ p_area_d=nf_odd*(sp_edge*(wf)+sp_poly*(wf)*(nf-1)/2)+ 
+  nf_even*(sp_poly*(wf)*nf/2) 
+ p_pj_s=nf_odd*(sp_edge*2+(wf)+(nf-1)/2*sp_poly*2)+nf_even  
+ *(sp_edge*2*2+(wf)*2+(nf/2-1)*sp_poly*2) 
+ p_pj_d=nf_odd*(sp_edge*2+(wf)+(nf-1)/2*sp_poly*2)+nf_even  
+ *(nf/2*sp_poly*2) 
+ p_pj_sg=nf*(wf) 
+ p_pj_dg=nf*(wf) 
+ p_area_tw=((wf)+2*sp_twell_w)*(2*sp_edge+nf*(lf)+(nf- 
+  1)*sp_poly+2*sp_twell_l) 
+ p_pj_tw=2*((wf)+2*sp_twell_w+2*sp_edge+nf*(lf)+(nf- 
+  1)*sp_poly+2*sp_twell_l) 
+ p_area_dnw=((wf)+2*sp_nwell_w)*(2*sp_edge+nf*(lf)+(nf- 
+  1)*sp_poly+2*sp_nwell_l) 
+ p_pj_dnw=2*((wf)+2*sp_nwell_w+2*sp_edge+nf*(lf)+(nf- 
+  1)*sp_poly+2*sp_nwell_l) 
+ dev_l=(nf-1)*4e-007+nf*lg+1.88e-006 
+ dev_w=wg+1.04e-006 
+ dev_access=dev_l*dev_w/(16*(dev_l*dev_l+dev_w*dev_w)) 
+ rbulk=75.46*dev_access-7992*wg+1.764e+004*lg+0.000503*nf 
+ rsh=8.5 
+ hdif=1.25e-07 
+ tcig=1+1.55e-3*(temp+dtemp-25) 
+ area=wg*(lg)*1e4*tcig*nf 
+ toxg=(2.64e-09+dtox_n_12_llrf)*1e2 
+ vdf0=3.11 
+ vdfl=-0.3e-08 
+ vdfw=3.5e-09 
+ vaf0=0.7 
+ vafl=-0.8e-10 
+ vafw=1.0e-10 
+ vdr0=5.78 
+ vdrl=0e-07 
+ vdrw=5.0e-09 
+ var0=0.60 
+ varl=0e-07 
+ varw=1.0e-10 
+ vdf=(vdf0+vdfl/(lg)+vdfw/(wg))*2.6e7*toxg 
+ vaf=(vaf0+vafl/(lg)+vafw/(wg))*2.6e7*toxg 
+ vdr=(vdr0+vdrl/(lg)+vdrw/(wg))*2.6e7*toxg 
+ var=(var0+varl/(lg)+varw/(wg))*2.6e7*toxg 
+ igf=2.1e-7*area*exp(-vdf)*pow(1/toxg,2.0) 
+ igr=2.1e-7*area/(lg)*exp(-vdr)*pow(1/toxg,2.0) 
n_12bpw_llrf ( 10 20 30 40 ) n_12bpw_llrf_main m=nf l=lf w=wf ad=0 as=0 pd=0 ps=0 sa=2.2u  
+  sb=2.2u 
rgc ( 2 22 ) resistor r=40.36*1e-12/(lg*wg*nf)*(1+drgc_n_12_llrf) 
rgi ( 22 21 ) resistor r=(3.2*wg/lg/nf)*(1+drgi_n_12_llrf) 
rch ( 21 20 ) resistor r=(1.21e3*lg/wg/nf)*(1+drch_n_12_llrf) isnoisy=0 
rdrain ( 1 10 ) resistor r=29.703*1e-6/(wg*nf) 
rsource ( 3 30 ) resistor r=29.703*1e-6/(wg*nf) 
rsubd ( 40 45 ) resistor r=7900*(0.4u+lg)/(wg*nf) 
rsubs ( 44 40 ) resistor r=7900*(0.4u+lg)/(wg*nf) 
rsubbe ( 40 4 ) resistor r=80*rbulk 
cgs_ext ( 22 30 ) capacitor c=1e-16*(3.46e-3*nf*nf+3.195*nf+4.615)* 
+  (1+dcgd_ext_n_12_llrf) 
cgd_ext ( 22 10 ) capacitor c=1e-16*(3.46e-3*nf*nf+3.195*nf+4.615)* 
+  (1+dcgd_ext_n_12_llrf) 
cds_ext ( 30 10 ) capacitor c=1e-16*(1.99e-4*wg*wg*nf*nf/lg/lg+0.347  
+ *wg*nf/lg+3.5)*(1+dcds_ext_n_12_llrf) 
djsb ( 44 30 ) sd_diode_core_nch m=1 area=p_area_s perim=p_pj_sg 
djsb_p ( 44 30 ) sdp_diode_core_nch m=1 area=1e-20 perim=p_pj_s 
djdb ( 45 10 ) sd_diode_core_nch m=1 area=p_area_d perim=p_pj_dg 
djdb_p ( 45 10 ) sdp_diode_core_nch m=1 area=1e-20 perim=p_pj_d 
dnw ( 4 50 ) dionw_l110e area=p_area_tw perim=p_pj_tw 
rdnw ( 50 5 ) resistor r=100*dev_access 
dnwp ( 60 50 ) dnw_psub area=p_area_dnw perim=p_pj_dnw 
rpsub ( 60 6 ) resistor r=390*dev_access 
//  ****Igate model*******************************************************************************  
//   
gigcd ( 20 10 ) bsource i =igf*pow((abs(v(20,10))+v(20,10))/2,vaf)-igr* 
+  pow((abs(v(20,10))-v(20,10))/2,var) 
gigcs ( 20 30 ) bsource i =igf*pow((abs(v(20,30))+v(20,30))/2,vaf)-igr* 
+  pow((abs(v(20,30))-v(20,30))/2,var) 
//  ***********************************************************************************************  
//   
  
model n_12bpw_llrf_main bsim3v3 type=n  
+  version=3.24              lmin=1.08e-007            lmax=3.24e-007 
+  wmin=8.1e-007            wmax=6.48e-006               binunit=2 
+  mobmod=1                  capmod=3                  nqsmod=0 
+  stimod=1                  tnom=25                    
+  tox=2.64e-009+dtox_n_12_llrf                      toxm=2.64e-009 
+  wint=7.28e-008            lint=1.0136e-008          dlc=4.085e-009 
+  dwc=4.507e-007            hdif=1.25e-007            ldif=9e-008 
+  xl=-9e-009+dxl_n_12_llrf+12e-009               
+  xw=1.4e-008+dxw_n_12_llrf                         xj=1.07e-007 
+  ngate=3.253e+021          ll=-2.4375e-012           wl=2e-015 
+  lln=0.5043                wln=1.04                  lw=5.94e-015 
+  ww=-2.228e-010            lwn=1                     wwn=0.354 
+  lwl=-4.617e-018           wwl=-1.8679e-017+dwwl_n_12_llrf 
+  llc=8.344e-012            wlc=0                     lwc=0 
+  wwc=-2.594e-009           lwlc=6.2e-019             wwlc=-8.316e-018 
+  xpart=0                   vth0=0.4496+dvth0_n_12_llrf 
+  pvth0=-3.073e-016+dpvth0_n_12_llrf              vfb=-0.8674 
+  k1=0.5537                 k2=-0.02355               k3=2.207+dk3_n_12_llrf 
+  lk3=4.2095e-006           wk3=-1.5411e-006          pk3=2.3441e-015 
+  k3b=-1                    wk3b=8.902e-007           pk3b=1.557e-013 
+  nlx=1.9077e-007+dnlx_n_12_llrf                    w0=5.514e-007 
+  dvt0=2.4277               dvt1=0.31156              dvt2=-0.0002724 
+  dvt0w=0.208               wdvt0w=9e-008             pdvt0w=-2.2782e-014 
+  dvt1w=800800              dvt2w=-0.0125             nch=7.35e+017 
+  voff=-0.1218              lvoff=-4.8e-009           pvoff=-1.6072e-015 
+  nfactor=0.19632           lnfactor=6.1834e-008      cdsc=5e-005 
+  cdscb=0                   cdscd=1e-005              cit=0.001921 
+  alpha0=4.557e-010         alpha1=0.00018            beta0=7.3 
+  lbeta0=-4.08e-008         eta0=0.07285              etab=-0.03213 
+  dsub=0.65162              pdsub=-1.8986e-014+dpdsub_n_12_llrf 
+  u0=0.03229+du0_n_12_llrf                          pu0=1.106e-014 
+  ua=0                      lua=7.879e-017            ub=6.836e-019 
+  lub=-1.96e-025            uc=4.961e-011             wuc=6.42e-019 
+  puc=1.2e-024              prwg=8.511                lprwg=-2.613e-007 
+  pprwg=-4.08e-013          prwb=-0.1656              wr=1 
+  rdsw=37.96+drdsw_n_12_llrf                        a0=1.822 
+  la0=2.59e-007             ags=0.1644+dags_n_12_llrf 
+  wags=0+dwags_n_12_llrf                            lags=9.014e-007 
+  a1=0.001913               a2=0.2936                 la2=1.03e-008 
+  b0=2.533e-007             pb0=4.8435e-020           b1=1.247e-006 
+  wb1=-1.4599e-013          vsat=67980+dvsat_n_12_llrf 
+  lvsat=0.0091724           pvsat=1.0226e-009+dpvsat_n_12_llrf 
+  keta=-0.046               lketa=7.8e-009            wketa=3.6e-009 
+  delta=0.02181             ldelta=2.903e-009         dwg=-1.965e-009 
+  pdwg=7.215e-024           dwb=4.807e-009            pclm=1.022 
+  lpclm=5.8748e-008         ppclm=8.046e-014          pdiblc1=0.006525 
+  ppdiblc1=1.176e-014       pdiblc2=0.004753          pdiblcb=-0.496 
+  drout=0.63792             pvag=1.187                pscbe1=4.24e+008 
+  pscbe2=1e-005             elm=5                     clc=5.808e-007 
+  cle=0.8204                cf=9.059e-011+dcf_n_12_llrf*fac 
+  ckappa=0.0064             acde=0.4                  moin=5.04 
+  lmoin=5.209e-007          vfbcv=-1.5                noff=2.016 
+  lnoff=8.44e-008           wnoff=2e-007              voffcv=-0.06344 
+  lvoffcv=-5.326e-009       cgbo=0                     
+  cgso=1.865e-010+dcgso_n_12_llrf*fac              
+  cgdo=1.865e-010+dcgdo_n_12_llrf*fac              
+  cgdl=3.16e-011+dcgdl_n_12_llrf*fac               
+  cgsl=3.16e-011+dcgsl_n_12_llrf*fac              kt1=-0.2615 
+  kt1l=1.481e-009           kt2=-0.0422               ute=-1.314 
+  wute=3.725e-008           pute=1.997e-014           ua1=2.951e-009 
+  ub1=-3.017e-018           uc1=-8.945e-011           prt=-194.1 
+  lprt=2.5e-005             at=122900                 wat=0.001815 
+  noia=2.73e+021            noib=44850                noic=-2.87e-014 
+  em=6658000                ef=0.8344                 noimod=2 
+  rsh=8.5                   js=8.81e-008              jsw=9.61e-014 
+  cj=0                      mj=0.258                  cjsw=0 
+  mjsw=0                    cjswg=0                   mjswg=0.7166 
+  pb=0.56                   pbsw=0.54                 pbswg=1.11 
+  xti=3                     tpb=0.001632              tpbsw=0.00031 
+  tpbswg=0.00182            tcj=0.0009555             tcjsw=0.0007325 
+  tcjswg=0.001436           nj=1.008                  saref=2.2e-006 
+  sbref=2.2e-006              wlod=0                    kvth0=3e-009 
+  lkvth0=-2.71e-011         wkvth0=0                  pkvth0=0 
+  llodvth=1                 wlodvth=1                 stk2=4e-010 
+  lodk2=1                   lodeta0=1                 ku0=-5.32e-008 
+  lku0=5.776e-008           wku0=0                    pku0=0 
+  llodku0=1.12              wlodku0=1                 kvsat=0.9 
+  steta0=0                  tku0=0                     
+  imax=0.1                  minr=0.01
  
model sd_diode_core_nch diode  
+  hcomp=1.0000e+00          imax=1.00e+14             level=1 
+  is=8.81e-08               isw=9.61e-14              n=1.008 
+  rs=0                      ik=5.28e+04               ikp=2780 
+  bv=13.36                  ibv=27.78                 trs=0.000495 
+  eg=1.16                   tbv1=-0.000684            tnom=25 
+  xti=3                     tlev=1                    tlevc=1 
+  cjo=0.00072+dcj_n_12_llrf                   mj=0.258 
+  vj=0.56                   cjsw=9.94e-11+dcjsw_n_12_llrf 
+  mjsw=0.13                 vjsw=0.54                 pta=0.001632 
+  ptp=0.00031               cta=0.0009555             ctp=0.0007325 
model sdp_diode_core_nch diode  
+  hcomp=1.0000e+00          imax=1.00e+14             level=1 
+  tnom=25                   cjo=0                      
+  cjsw=5e-10+dcjswg_n_12_llrf                 mjsw=0.7166 
+  vjsw=1.11                 ctp=0.001436              xti=3 
+  eg=1.16                   tlev=0                    tlevc=1 
//  Device nw/psub diode   
//    
model dionw_l110e diode  
+  hcomp=1.0000e+00          imax=1.00e+14             level=1 
+  area=1.68e-007            perim=0.00469             tnom=25 
+  is=2.05e-006              isw=5.34e-011             ik=17856 
+  bv=9.662                  ibv=5.952                 ikp=595.2 
+  n=1.0525                  rs=3.0891e-007             
+  cjo=8.28e-005*(1+dcj_nwtw_n_12bpw_llrf)          
+  cjp=9.92e-010*(1+dcjp_nwtw_n_12bpw_llrf)        vj=0.588 
+  vjsw=0.62                 mj=0.474                  mjsw=0.27 
+  tlev=1                    tlevc=1                   trs=0.00322 
+  tbv1=-0.000539            xti=5.4936                cta=0.00332 
+  ctp=0.001                 eg=1.16                   pta=0.0028 
+  ptp=0.001                  
//    
//  Device dnw/psub diode   
//    
model dnw_psub diode  
+  hcomp=1.0000e+00          imax=1.00e+14             level=1 
+  area=3.2e-008             perim=0.00032             tnom=25 
+  is=1.3886e-006            isw=7.8545e-011           ik=6738.8 
+  bv=9.8407                 ibv=5.952                 ikp=595.2 
+  n=1.0073                  rs=3.4225e-007             
+  cjo=0.00017814*(1+dcj_nw_n_12bpw_llrf)           
+  cjp=1.9409e-009*(1+dcjp_nw_n_12bpw_llrf)        vj=0.34911 
+  vjsw=0.56633              mj=0.2415                 mjsw=0.30262 
+  tlev=1                    tlevc=1                   trs=0.0045789 
+  tbv1=-0.000539            xti=2.4515                cta=0.0027908 
+  ctp=0.0013                eg=1.16                   pta=0.0022245 
+  ptp=0.001                  
//    

ends n_12bpw_llrf 
 

